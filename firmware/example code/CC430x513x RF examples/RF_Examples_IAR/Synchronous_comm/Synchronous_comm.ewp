# IAR project Synchronous_comm.ewp, settings and files
configuration TX_MHZ_868 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MHZ_868
  ICC430.newCCIncludePaths: HAL/
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnkCC430F6137.xcl
  XLINK.XlinkStackSize: 1
configuration RX_MHZ_868 (MSP430, debug)
  as the first configuration, except:
configuration TX_MHZ_915 (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MHZ_915
configuration RX_MHZ_915 (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: MHZ_915
  group (top)
    ./: Synchronous_comm_RX.c Synchronous_comm_TX.c
  group HAL
    HAL/: hal_pmm.c RF1A.c RfRegSettings_RX.c RfRegSettings_TX.c
